# Keil uVision project UART_Appl_Ctrl.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: UART_Appl_Ctrl +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 conf.h constants.h main.c main.h port.h uart.c uart.h
